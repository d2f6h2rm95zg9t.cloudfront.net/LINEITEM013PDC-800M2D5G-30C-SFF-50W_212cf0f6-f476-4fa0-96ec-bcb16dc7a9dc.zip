!Agilent Technologies,N5234A,MY52241180,A.10.00.00
!Agilent N5234A: A.10.00.00
!Date: Tuesday, August 18, 2015 23:55:37
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (weakly coupled two-port):
!   401 points, 800 MHz to 2.5 GHz, reference 50 ohm
!   highest |S21| = -58.84 dB at 2.496 GHz (marker M1); lowest = -84.0 dB at 1.918 GHz (marker M2)
!   lowest |S11| = -58.9 dB at 1.782 GHz (marker M3), VSWR 1.00, Z = 50.1 + j0.0325 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -48.3 to -28.5 dB; largest |S21 - S12| = 0.00023
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 800 MHz  -47.1  -71.8  -71.6  -37.5
! 851 MHz  -49.5  -72.2  -70.8  -37.4
! 948.8 MHz  -39.9  -69.7  -69.1  -38.4
! 1.085 GHz  -33.9  -66.9  -66.2  -41.0
! 1.225 GHz  -31.5  -67.2  -66.6  -46.2
! 1.369 GHz  -30.9  -66.8  -66.3  -39.3
! 1.591 GHz  -34.5  -66.1  -68.6  -34.1
! 1.65 GHz  -37.3  -67.9  -68.6  -33.4
! 1.692 GHz  -40.1  -68.5  -69.1  -33.6
! 1.731 GHz  -44.0  -71.3  -72.5  -33.6
! 1.782 GHz  -58.9  -70.1  -72.6  -34.1
! 1.841 GHz  -43.5  -74.1  -72.7  -35.1
! 1.85 GHz  -42.0  -73.8  -73.8  -35.2
! 1.892 GHz  -37.8  -73.2  -78.7  -36.4
! 1.918 GHz  -36.1  -84.0  -71.3  -37.2
! 1.935 GHz  -35.1  -74.5  -80.5  -37.7
! 1.994 GHz  -32.1  -75.4  -73.8  -41.5
! 2.037 GHz  -30.6  -68.6  -72.3  -44.7
! 2.088 GHz  -29.2  -70.5  -69.9  -48.0
! 2.22 GHz  -26.9  -64.6  -63.6  -36.9
! 2.496 GHz  -26.4  -58.8  -59.2  -28.6
! 2.5 GHz  -26.4  -59.4  -58.8  -28.5
